# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: @{define}
  ICCARM.CCIncludePath2: $PROJ_DIR$@{relative_path}\@{inc}
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$@{relative_path}\@{inc}
  OBJCOPY.OOCOutputFile: @{extout.name}
  ILINK.IlinkOutputFile: $PROJ_FNAME$.elf
  ILINK.IlinkIcfFile: $PROJ_DIR$@{relative_path}\@{dev.icf}
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
